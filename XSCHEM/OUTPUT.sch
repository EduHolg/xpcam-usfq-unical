v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 140 -2550 140 -2500 {lab=#net1}
N 350 -2550 350 -2490 {lab=#net2}
N 260 -2330 350 -2330 {lab=#net3}
N 260 -2440 320 -2440 {lab=#net3}
N 320 -2440 320 -2430 {lab=#net3}
N 320 -2430 350 -2430 {lab=#net3}
N 260 -2380 260 -2330 {lab=#net3}
N 140 -2440 260 -2440 {lab=#net3}
N 140 -2330 260 -2330 {lab=#net3}
N 260 -2380 410 -2380 {lab=#net3}
N 260 -2440 260 -2380 {lab=#net3}
N -20 -2540 -20 -2420 {lab=VDD}
N -20 -2420 -20 -2410 {lab=VDD}
N -20 -2540 -10 -2540 {lab=VDD}
N -20 -2610 -20 -2540 {lab=VDD}
N -20 -2420 -10 -2420 {lab=VDD}
N 230 -2130 370 -2130 {lab=VSS}
N -30 -2350 -20 -2350 {lab=VSS}
N 70 -2580 100 -2580 {lab=#net4}
N -80 -2380 -60 -2380 {lab=S0}
N -20 -2350 -20 -2130 {lab=VSS}
N 140 -2580 160 -2580 {lab=VDD}
N 160 -2610 160 -2580 {lab=VDD}
N -20 -2610 160 -2610 {lab=VDD}
N 140 -2470 160 -2470 {lab=VDD}
N 160 -2580 160 -2470 {lab=VDD}
N 350 -2580 370 -2580 {lab=VDD}
N 160 -2610 370 -2610 {lab=VDD}
N 370 -2610 370 -2580 {lab=VDD}
N 370 -2580 370 -2460 {lab=VDD}
N 350 -2460 370 -2460 {lab=VDD}
N 140 -2160 160 -2160 {lab=VSS}
N 160 -2160 160 -2130 {lab=VSS}
N -20 -2130 160 -2130 {lab=VSS}
N 350 -2160 370 -2160 {lab=VSS}
N 370 -2160 370 -2130 {lab=VSS}
N 140 -2300 160 -2300 {lab=VSS}
N 160 -2300 160 -2160 {lab=VSS}
N 350 -2300 370 -2300 {lab=VSS}
N 370 -2300 370 -2160 {lab=VSS}
N 70 -2580 70 -2160 {lab=#net4}
N 70 -2160 100 -2160 {lab=#net4}
N 290 -2580 310 -2580 {lab=VSS}
N 290 -2580 290 -2160 {lab=VSS}
N 290 -2160 310 -2160 {lab=VSS}
N 30 -2380 100 -2380 {lab=#net5}
N 100 -2390 100 -2380 {lab=#net5}
N 100 -2390 320 -2390 {lab=#net5}
N 100 -2470 100 -2390 {lab=#net5}
N 320 -2390 320 -2310 {lab=#net5}
N 310 -2310 320 -2310 {lab=#net5}
N 310 -2310 310 -2300 {lab=#net5}
N 310 -2520 310 -2460 {lab=S0}
N -60 -2520 310 -2520 {lab=S0}
N -60 -2520 -60 -2380 {lab=S0}
N -70 -2300 100 -2300 {lab=S0}
N -80 -2380 -80 -2300 {lab=S0}
N 140 -2270 140 -2190 {lab=#net6}
N 350 -2270 350 -2190 {lab=#net7}
N 450 -2350 450 -2130 {lab=VSS}
N 450 -2610 450 -2410 {lab=VDD}
N 370 -2610 450 -2610 {lab=VDD}
N -80 -2610 -20 -2610 {lab=VDD}
N -330 -2610 -330 -2590 {lab=VDD}
N -240 -2130 -20 -2130 {lab=VSS}
N -370 -2130 -360 -2470 {lab=VSS}
N -360 -2470 -330 -2470 {lab=VSS}
N -250 -2580 70 -2580 {lab=#net4}
N -250 -2580 -250 -2530 {lab=#net4}
N -260 -2530 -250 -2530 {lab=#net4}
N -450 -2550 -380 -2550 {lab=D1}
N 500 -2380 620 -2380 {lab=#net8}
N 580 -2340 620 -2340 {lab=CLK}
N 670 -2610 670 -2420 {lab=VDD}
N 450 -2610 670 -2610 {lab=VDD}
N 450 -2130 670 -2130 {lab=VSS}
N 370 -2130 450 -2130 {lab=VSS}
N 740 -2360 810 -2360 {lab=#net9}
N 130 -1990 130 -1940 {lab=#net10}
N 340 -1990 340 -1930 {lab=#net11}
N 250 -1770 340 -1770 {lab=#net12}
N 250 -1880 310 -1880 {lab=#net12}
N 310 -1880 310 -1870 {lab=#net12}
N 310 -1870 340 -1870 {lab=#net12}
N 250 -1820 250 -1770 {lab=#net12}
N 130 -1880 250 -1880 {lab=#net12}
N 130 -1770 250 -1770 {lab=#net12}
N 250 -1820 400 -1820 {lab=#net12}
N 250 -1880 250 -1820 {lab=#net12}
N -30 -1980 -30 -1860 {lab=VDD}
N -30 -1860 -30 -1850 {lab=VDD}
N -30 -1980 -20 -1980 {lab=VDD}
N -30 -2050 -30 -1980 {lab=VDD}
N -30 -1860 -20 -1860 {lab=VDD}
N 150 -1570 360 -1570 {lab=VSS}
N -40 -1790 -30 -1790 {lab=VSS}
N 60 -2020 90 -2020 {lab=#net13}
N -90 -1820 -70 -1820 {lab=S0}
N -30 -1790 -30 -1570 {lab=VSS}
N 130 -2020 150 -2020 {lab=VDD}
N 150 -2050 150 -2020 {lab=VDD}
N -30 -2050 150 -2050 {lab=VDD}
N 130 -1910 150 -1910 {lab=VDD}
N 150 -2020 150 -1910 {lab=VDD}
N 340 -2020 360 -2020 {lab=VDD}
N 150 -2050 360 -2050 {lab=VDD}
N 360 -2050 360 -2020 {lab=VDD}
N 360 -2020 360 -1900 {lab=VDD}
N 340 -1900 360 -1900 {lab=VDD}
N 130 -1600 150 -1600 {lab=VSS}
N 150 -1600 150 -1570 {lab=VSS}
N -30 -1570 150 -1570 {lab=VSS}
N 340 -1600 360 -1600 {lab=VSS}
N 360 -1600 360 -1570 {lab=VSS}
N 130 -1740 150 -1740 {lab=VSS}
N 150 -1740 150 -1600 {lab=VSS}
N 340 -1740 360 -1740 {lab=VSS}
N 360 -1740 360 -1600 {lab=VSS}
N 60 -2020 60 -1600 {lab=#net13}
N 60 -1600 90 -1600 {lab=#net13}
N 280 -2020 300 -2020 {lab=#net9}
N 280 -2020 280 -1600 {lab=#net9}
N 270 -2020 280 -2020 {lab=#net9}
N 280 -1600 300 -1600 {lab=#net9}
N 20 -1820 90 -1820 {lab=#net14}
N 90 -1830 90 -1820 {lab=#net14}
N 90 -1830 310 -1830 {lab=#net14}
N 90 -1910 90 -1830 {lab=#net14}
N 310 -1830 310 -1750 {lab=#net14}
N 300 -1750 310 -1750 {lab=#net14}
N 300 -1750 300 -1740 {lab=#net14}
N 300 -1960 300 -1900 {lab=S0}
N -70 -1960 300 -1960 {lab=S0}
N -70 -1960 -70 -1820 {lab=S0}
N -90 -1740 90 -1740 {lab=S0}
N -90 -1820 -90 -1740 {lab=S0}
N 130 -1710 130 -1630 {lab=#net15}
N 340 -1710 340 -1630 {lab=#net16}
N 440 -1790 440 -1570 {lab=VSS}
N 440 -2050 440 -1850 {lab=VDD}
N 360 -2050 440 -2050 {lab=VDD}
N -190 -2050 -30 -2050 {lab=VDD}
N -340 -2050 -340 -2030 {lab=VDD}
N -210 -1570 -30 -1570 {lab=VSS}
N -380 -1570 -370 -1910 {lab=VSS}
N -370 -1910 -340 -1910 {lab=VSS}
N -260 -2020 60 -2020 {lab=#net13}
N -260 -2020 -260 -1970 {lab=#net13}
N -270 -1970 -260 -1970 {lab=#net13}
N -460 -1990 -390 -1990 {lab=D2}
N 490 -1820 610 -1820 {lab=#net17}
N 660 -2050 660 -1860 {lab=VDD}
N 440 -2050 660 -2050 {lab=VDD}
N 440 -1570 660 -1570 {lab=VSS}
N 360 -1570 440 -1570 {lab=VSS}
N 730 -1800 800 -1800 {lab=#net18}
N 810 -2360 810 -2100 {lab=#net9}
N 280 -2100 810 -2100 {lab=#net9}
N 280 -2100 280 -2020 {lab=#net9}
N 130 -1460 130 -1410 {lab=#net19}
N 340 -1460 340 -1400 {lab=#net20}
N 250 -1240 340 -1240 {lab=#net21}
N 250 -1350 310 -1350 {lab=#net21}
N 310 -1350 310 -1340 {lab=#net21}
N 310 -1340 340 -1340 {lab=#net21}
N 250 -1290 250 -1240 {lab=#net21}
N 130 -1350 250 -1350 {lab=#net21}
N 130 -1240 250 -1240 {lab=#net21}
N 250 -1290 400 -1290 {lab=#net21}
N 250 -1350 250 -1290 {lab=#net21}
N -30 -1450 -30 -1330 {lab=VDD}
N -30 -1330 -30 -1320 {lab=VDD}
N -30 -1450 -20 -1450 {lab=VDD}
N -30 -1520 -30 -1450 {lab=VDD}
N -30 -1330 -20 -1330 {lab=VDD}
N 150 -1040 360 -1040 {lab=VSS}
N -40 -1260 -30 -1260 {lab=VSS}
N 60 -1490 90 -1490 {lab=#net22}
N -90 -1290 -70 -1290 {lab=S0}
N -30 -1260 -30 -1040 {lab=VSS}
N 130 -1490 150 -1490 {lab=VDD}
N 150 -1520 150 -1490 {lab=VDD}
N -30 -1520 150 -1520 {lab=VDD}
N 130 -1380 150 -1380 {lab=VDD}
N 150 -1490 150 -1380 {lab=VDD}
N 340 -1490 360 -1490 {lab=VDD}
N 150 -1520 360 -1520 {lab=VDD}
N 360 -1520 360 -1490 {lab=VDD}
N 360 -1490 360 -1370 {lab=VDD}
N 340 -1370 360 -1370 {lab=VDD}
N 130 -1070 150 -1070 {lab=VSS}
N 150 -1070 150 -1040 {lab=VSS}
N -30 -1040 150 -1040 {lab=VSS}
N 340 -1070 360 -1070 {lab=VSS}
N 360 -1070 360 -1040 {lab=VSS}
N 130 -1210 150 -1210 {lab=VSS}
N 150 -1210 150 -1070 {lab=VSS}
N 340 -1210 360 -1210 {lab=VSS}
N 360 -1210 360 -1070 {lab=VSS}
N 60 -1490 60 -1070 {lab=#net22}
N 60 -1070 90 -1070 {lab=#net22}
N 280 -1490 300 -1490 {lab=#net18}
N 280 -1490 280 -1070 {lab=#net18}
N 270 -1490 280 -1490 {lab=#net18}
N 280 -1070 300 -1070 {lab=#net18}
N 20 -1290 90 -1290 {lab=#net23}
N 90 -1300 90 -1290 {lab=#net23}
N 90 -1300 310 -1300 {lab=#net23}
N 90 -1380 90 -1300 {lab=#net23}
N 310 -1300 310 -1220 {lab=#net23}
N 300 -1220 310 -1220 {lab=#net23}
N 300 -1220 300 -1210 {lab=#net23}
N 300 -1430 300 -1370 {lab=S0}
N -70 -1430 300 -1430 {lab=S0}
N -70 -1430 -70 -1290 {lab=S0}
N -90 -1210 90 -1210 {lab=S0}
N -90 -1290 -90 -1210 {lab=S0}
N 130 -1180 130 -1100 {lab=#net24}
N 340 -1180 340 -1100 {lab=#net25}
N 440 -1260 440 -1040 {lab=VSS}
N 440 -1520 440 -1320 {lab=VDD}
N 360 -1520 440 -1520 {lab=VDD}
N -190 -1520 -30 -1520 {lab=VDD}
N -340 -1520 -340 -1500 {lab=VDD}
N -210 -1040 -30 -1040 {lab=VSS}
N -370 -1380 -340 -1380 {lab=VSS}
N -260 -1490 60 -1490 {lab=#net22}
N -260 -1490 -260 -1440 {lab=#net22}
N -270 -1440 -260 -1440 {lab=#net22}
N -460 -1460 -390 -1460 {lab=D3}
N 490 -1290 610 -1290 {lab=#net26}
N 660 -1520 660 -1330 {lab=VDD}
N 440 -1520 660 -1520 {lab=VDD}
N 440 -1040 660 -1040 {lab=VSS}
N 360 -1040 440 -1040 {lab=VSS}
N 730 -1270 800 -1270 {lab=#net27}
N 120 -900 120 -850 {lab=#net28}
N 330 -900 330 -840 {lab=#net29}
N 240 -680 330 -680 {lab=#net30}
N 240 -790 300 -790 {lab=#net30}
N 300 -790 300 -780 {lab=#net30}
N 300 -780 330 -780 {lab=#net30}
N 240 -730 240 -680 {lab=#net30}
N 120 -790 240 -790 {lab=#net30}
N 120 -680 240 -680 {lab=#net30}
N 240 -730 390 -730 {lab=#net30}
N 240 -790 240 -730 {lab=#net30}
N -40 -890 -40 -770 {lab=VDD}
N -40 -770 -40 -760 {lab=VDD}
N -40 -890 -30 -890 {lab=VDD}
N -40 -960 -40 -890 {lab=VDD}
N -40 -770 -30 -770 {lab=VDD}
N 140 -480 350 -480 {lab=VSS}
N -50 -700 -40 -700 {lab=VSS}
N 50 -930 80 -930 {lab=#net31}
N -100 -730 -80 -730 {lab=S0}
N -40 -700 -40 -480 {lab=VSS}
N 120 -930 140 -930 {lab=VDD}
N 140 -960 140 -930 {lab=VDD}
N -40 -960 140 -960 {lab=VDD}
N 120 -820 140 -820 {lab=VDD}
N 140 -930 140 -820 {lab=VDD}
N 330 -930 350 -930 {lab=VDD}
N 140 -960 350 -960 {lab=VDD}
N 350 -960 350 -930 {lab=VDD}
N 350 -930 350 -810 {lab=VDD}
N 330 -810 350 -810 {lab=VDD}
N 120 -510 140 -510 {lab=VSS}
N 140 -510 140 -480 {lab=VSS}
N -40 -480 140 -480 {lab=VSS}
N 330 -510 350 -510 {lab=VSS}
N 350 -510 350 -480 {lab=VSS}
N 120 -650 140 -650 {lab=VSS}
N 140 -650 140 -510 {lab=VSS}
N 330 -650 350 -650 {lab=VSS}
N 350 -650 350 -510 {lab=VSS}
N 50 -930 50 -510 {lab=#net31}
N 50 -510 80 -510 {lab=#net31}
N 270 -930 290 -930 {lab=#net27}
N 270 -930 270 -510 {lab=#net27}
N 260 -930 270 -930 {lab=#net27}
N 270 -510 290 -510 {lab=#net27}
N 10 -730 80 -730 {lab=#net32}
N 80 -740 80 -730 {lab=#net32}
N 80 -740 300 -740 {lab=#net32}
N 80 -820 80 -740 {lab=#net32}
N 300 -740 300 -660 {lab=#net32}
N 290 -660 300 -660 {lab=#net32}
N 290 -660 290 -650 {lab=#net32}
N 290 -870 290 -810 {lab=S0}
N -80 -870 290 -870 {lab=S0}
N -80 -860 -80 -730 {lab=S0}
N -100 -650 80 -650 {lab=S0}
N -100 -730 -100 -650 {lab=S0}
N 120 -620 120 -540 {lab=#net33}
N 330 -620 330 -540 {lab=#net34}
N 430 -700 430 -480 {lab=VSS}
N 430 -960 430 -760 {lab=VDD}
N 350 -960 430 -960 {lab=VDD}
N -190 -960 -40 -960 {lab=VDD}
N -350 -960 -350 -940 {lab=VDD}
N -240 -480 -40 -480 {lab=VSS}
N -390 -480 -380 -820 {lab=VSS}
N -380 -820 -350 -820 {lab=VSS}
N -270 -930 50 -930 {lab=#net31}
N -270 -930 -270 -880 {lab=#net31}
N -280 -880 -270 -880 {lab=#net31}
N -470 -900 -400 -900 {lab=D4}
N 480 -730 600 -730 {lab=#net35}
N 650 -960 650 -770 {lab=VDD}
N 430 -960 650 -960 {lab=VDD}
N 430 -480 650 -480 {lab=VSS}
N 350 -480 430 -480 {lab=VSS}
N 720 -710 790 -710 {lab=#net36}
N 800 -1270 800 -1010 {lab=#net27}
N 270 -1010 800 -1010 {lab=#net27}
N 270 -1010 270 -930 {lab=#net27}
N 800 -1800 800 -1560 {lab=#net18}
N 270 -1560 800 -1560 {lab=#net18}
N 270 -1560 270 -1490 {lab=#net18}
N 80 -330 80 -280 {lab=#net37}
N 290 -330 290 -270 {lab=#net38}
N 200 -110 290 -110 {lab=#net39}
N 200 -220 260 -220 {lab=#net39}
N 260 -220 260 -210 {lab=#net39}
N 260 -210 290 -210 {lab=#net39}
N 200 -160 200 -110 {lab=#net39}
N 80 -220 200 -220 {lab=#net39}
N 80 -110 200 -110 {lab=#net39}
N 200 -160 350 -160 {lab=#net39}
N 200 -220 200 -160 {lab=#net39}
N -80 -320 -80 -200 {lab=VDD}
N -80 -200 -80 -190 {lab=VDD}
N -80 -320 -70 -320 {lab=VDD}
N -80 -390 -80 -320 {lab=VDD}
N -80 -200 -70 -200 {lab=VDD}
N 100 90 310 90 {lab=VSS}
N -90 -130 -80 -130 {lab=VSS}
N 10 -360 40 -360 {lab=#net40}
N -140 -160 -120 -160 {lab=S0}
N -80 -130 -80 90 {lab=VSS}
N 80 -360 100 -360 {lab=VDD}
N 100 -390 100 -360 {lab=VDD}
N -80 -390 100 -390 {lab=VDD}
N 80 -250 100 -250 {lab=VDD}
N 100 -360 100 -250 {lab=VDD}
N 290 -360 310 -360 {lab=VDD}
N 100 -390 310 -390 {lab=VDD}
N 310 -390 310 -360 {lab=VDD}
N 310 -360 310 -240 {lab=VDD}
N 290 -240 310 -240 {lab=VDD}
N 80 60 100 60 {lab=VSS}
N 100 60 100 90 {lab=VSS}
N -80 90 100 90 {lab=VSS}
N 290 60 310 60 {lab=VSS}
N 310 60 310 90 {lab=VSS}
N 80 -80 100 -80 {lab=VSS}
N 100 -80 100 60 {lab=VSS}
N 290 -80 310 -80 {lab=VSS}
N 310 -80 310 60 {lab=VSS}
N 10 -360 10 60 {lab=#net40}
N 10 60 40 60 {lab=#net40}
N 230 -360 250 -360 {lab=#net36}
N 230 -360 230 60 {lab=#net36}
N 220 -360 230 -360 {lab=#net36}
N 230 60 250 60 {lab=#net36}
N -30 -160 40 -160 {lab=#net41}
N 40 -170 40 -160 {lab=#net41}
N 40 -170 260 -170 {lab=#net41}
N 40 -250 40 -170 {lab=#net41}
N 260 -170 260 -90 {lab=#net41}
N 250 -90 260 -90 {lab=#net41}
N 250 -90 250 -80 {lab=#net41}
N 250 -300 250 -240 {lab=S0}
N -100 -300 250 -300 {lab=S0}
N -120 -300 -120 -160 {lab=S0}
N -140 -80 40 -80 {lab=S0}
N -140 -160 -140 -80 {lab=S0}
N 80 -50 80 30 {lab=#net42}
N 290 -50 290 30 {lab=#net43}
N 390 -130 390 90 {lab=VSS}
N 390 -390 390 -190 {lab=VDD}
N 310 -390 390 -390 {lab=VDD}
N -190 -390 -80 -390 {lab=VDD}
N -390 -390 -390 -370 {lab=VDD}
N -430 90 -420 -250 {lab=VSS}
N -420 -250 -390 -250 {lab=VSS}
N -310 -360 10 -360 {lab=#net40}
N -310 -360 -310 -310 {lab=#net40}
N -320 -310 -310 -310 {lab=#net40}
N -510 -330 -440 -330 {lab=D5}
N 440 -160 560 -160 {lab=#net44}
N 610 -390 610 -200 {lab=VDD}
N 390 -390 610 -390 {lab=VDD}
N 390 90 610 90 {lab=VSS}
N 310 90 390 90 {lab=VSS}
N 680 -140 750 -140 {lab=#net45}
N 70 230 70 280 {lab=#net46}
N 280 230 280 290 {lab=#net47}
N 190 450 280 450 {lab=#net48}
N 190 340 250 340 {lab=#net48}
N 250 340 250 350 {lab=#net48}
N 250 350 280 350 {lab=#net48}
N 190 400 190 450 {lab=#net48}
N 70 340 190 340 {lab=#net48}
N 70 450 190 450 {lab=#net48}
N 190 400 340 400 {lab=#net48}
N 190 340 190 400 {lab=#net48}
N -90 240 -90 360 {lab=VDD}
N -90 360 -90 370 {lab=VDD}
N -90 240 -80 240 {lab=VDD}
N -90 170 -90 240 {lab=VDD}
N -90 360 -80 360 {lab=VDD}
N 90 650 300 650 {lab=VSS}
N -100 430 -90 430 {lab=VSS}
N 0 200 30 200 {lab=#net49}
N -150 400 -130 400 {lab=S0}
N -90 430 -90 650 {lab=VSS}
N 70 200 90 200 {lab=VDD}
N 90 170 90 200 {lab=VDD}
N -90 170 90 170 {lab=VDD}
N 70 310 90 310 {lab=VDD}
N 90 200 90 310 {lab=VDD}
N 280 200 300 200 {lab=VDD}
N 90 170 300 170 {lab=VDD}
N 300 170 300 200 {lab=VDD}
N 300 200 300 320 {lab=VDD}
N 280 320 300 320 {lab=VDD}
N 70 620 90 620 {lab=VSS}
N 90 620 90 650 {lab=VSS}
N -90 650 90 650 {lab=VSS}
N 280 620 300 620 {lab=VSS}
N 300 620 300 650 {lab=VSS}
N 70 480 90 480 {lab=VSS}
N 90 480 90 620 {lab=VSS}
N 280 480 300 480 {lab=VSS}
N 300 480 300 620 {lab=VSS}
N 0 200 0 620 {lab=#net49}
N 0 620 30 620 {lab=#net49}
N 220 200 240 200 {lab=#net45}
N 220 200 220 620 {lab=#net45}
N 210 200 220 200 {lab=#net45}
N 220 620 240 620 {lab=#net45}
N -40 400 30 400 {lab=#net50}
N 30 390 30 400 {lab=#net50}
N 30 390 250 390 {lab=#net50}
N 30 310 30 390 {lab=#net50}
N 250 390 250 470 {lab=#net50}
N 240 470 250 470 {lab=#net50}
N 240 470 240 480 {lab=#net50}
N 240 260 240 320 {lab=S0}
N -130 260 240 260 {lab=S0}
N -130 260 -130 400 {lab=S0}
N -150 480 30 480 {lab=S0}
N -150 400 -150 480 {lab=S0}
N 70 510 70 590 {lab=#net51}
N 280 510 280 590 {lab=#net52}
N 380 430 380 650 {lab=VSS}
N 380 170 380 370 {lab=VDD}
N 300 170 380 170 {lab=VDD}
N -190 170 -90 170 {lab=VDD}
N -400 170 -400 190 {lab=VDD}
N -440 650 -430 310 {lab=VSS}
N -430 310 -400 310 {lab=VSS}
N -320 200 0 200 {lab=#net49}
N -320 200 -320 250 {lab=#net49}
N -330 250 -320 250 {lab=#net49}
N 430 400 550 400 {lab=#net53}
N 600 170 600 360 {lab=VDD}
N 380 170 600 170 {lab=VDD}
N 380 650 600 650 {lab=VSS}
N 300 650 380 650 {lab=VSS}
N 670 420 740 420 {lab=#net54}
N 750 -140 750 120 {lab=#net45}
N 220 120 750 120 {lab=#net45}
N 220 120 220 200 {lab=#net45}
N 70 760 70 810 {lab=#net55}
N 280 760 280 820 {lab=#net56}
N 190 980 280 980 {lab=#net57}
N 190 870 250 870 {lab=#net57}
N 250 870 250 880 {lab=#net57}
N 250 880 280 880 {lab=#net57}
N 190 930 190 980 {lab=#net57}
N 70 870 190 870 {lab=#net57}
N 70 980 190 980 {lab=#net57}
N 190 930 340 930 {lab=#net57}
N 190 870 190 930 {lab=#net57}
N -90 770 -90 890 {lab=VDD}
N -90 890 -90 900 {lab=VDD}
N -90 770 -80 770 {lab=VDD}
N -90 700 -90 770 {lab=VDD}
N -90 890 -80 890 {lab=VDD}
N 90 1180 300 1180 {lab=VSS}
N -100 960 -90 960 {lab=VSS}
N 0 730 30 730 {lab=#net58}
N -150 930 -130 930 {lab=S0}
N -90 960 -90 1180 {lab=VSS}
N 70 730 90 730 {lab=VDD}
N 90 700 90 730 {lab=VDD}
N -90 700 90 700 {lab=VDD}
N 70 840 90 840 {lab=VDD}
N 90 730 90 840 {lab=VDD}
N 280 730 300 730 {lab=VDD}
N 90 700 300 700 {lab=VDD}
N 300 700 300 730 {lab=VDD}
N 300 730 300 850 {lab=VDD}
N 280 850 300 850 {lab=VDD}
N 70 1150 90 1150 {lab=VSS}
N 90 1150 90 1180 {lab=VSS}
N -90 1180 90 1180 {lab=VSS}
N 280 1150 300 1150 {lab=VSS}
N 300 1150 300 1180 {lab=VSS}
N 70 1010 90 1010 {lab=VSS}
N 90 1010 90 1150 {lab=VSS}
N 280 1010 300 1010 {lab=VSS}
N 300 1010 300 1150 {lab=VSS}
N 0 730 0 1150 {lab=#net58}
N 0 1150 30 1150 {lab=#net58}
N 220 730 240 730 {lab=#net54}
N 220 730 220 1150 {lab=#net54}
N 210 730 220 730 {lab=#net54}
N 220 1150 240 1150 {lab=#net54}
N -40 930 30 930 {lab=#net59}
N 30 920 30 930 {lab=#net59}
N 30 920 250 920 {lab=#net59}
N 30 840 30 920 {lab=#net59}
N 250 920 250 1000 {lab=#net59}
N 240 1000 250 1000 {lab=#net59}
N 240 1000 240 1010 {lab=#net59}
N 240 790 240 850 {lab=S0}
N -130 790 240 790 {lab=S0}
N -130 790 -130 930 {lab=S0}
N -150 1010 30 1010 {lab=S0}
N -150 930 -150 1010 {lab=S0}
N 70 1040 70 1120 {lab=#net60}
N 280 1040 280 1120 {lab=#net61}
N 380 960 380 1180 {lab=VSS}
N 380 700 380 900 {lab=VDD}
N 300 700 380 700 {lab=VDD}
N -200 700 -90 700 {lab=VDD}
N -400 700 -400 720 {lab=VDD}
N -440 1180 -430 840 {lab=VSS}
N -430 840 -400 840 {lab=VSS}
N -320 730 0 730 {lab=#net58}
N -320 730 -320 780 {lab=#net58}
N -330 780 -320 780 {lab=#net58}
N 430 930 550 930 {lab=#net62}
N 600 700 600 890 {lab=VDD}
N 380 700 600 700 {lab=VDD}
N 380 1180 600 1180 {lab=VSS}
N 300 1180 380 1180 {lab=VSS}
N 670 950 740 950 {lab=#net63}
N 60 1320 60 1370 {lab=#net64}
N 270 1320 270 1380 {lab=#net65}
N 180 1540 270 1540 {lab=#net66}
N 180 1430 240 1430 {lab=#net66}
N 240 1430 240 1440 {lab=#net66}
N 240 1440 270 1440 {lab=#net66}
N 180 1490 180 1540 {lab=#net66}
N 60 1430 180 1430 {lab=#net66}
N 60 1540 180 1540 {lab=#net66}
N 180 1490 330 1490 {lab=#net66}
N 180 1430 180 1490 {lab=#net66}
N -100 1330 -100 1450 {lab=VDD}
N -100 1450 -100 1460 {lab=VDD}
N -100 1330 -90 1330 {lab=VDD}
N -100 1260 -100 1330 {lab=VDD}
N -100 1450 -90 1450 {lab=VDD}
N 80 1740 290 1740 {lab=VSS}
N -110 1520 -100 1520 {lab=VSS}
N -10 1290 20 1290 {lab=#net67}
N -160 1490 -140 1490 {lab=S0}
N -100 1520 -100 1740 {lab=VSS}
N 60 1290 80 1290 {lab=VDD}
N 80 1260 80 1290 {lab=VDD}
N -100 1260 80 1260 {lab=VDD}
N 60 1400 80 1400 {lab=VDD}
N 80 1290 80 1400 {lab=VDD}
N 270 1290 290 1290 {lab=VDD}
N 80 1260 290 1260 {lab=VDD}
N 290 1260 290 1290 {lab=VDD}
N 290 1290 290 1410 {lab=VDD}
N 270 1410 290 1410 {lab=VDD}
N 60 1710 80 1710 {lab=VSS}
N 80 1710 80 1740 {lab=VSS}
N -100 1740 80 1740 {lab=VSS}
N 270 1710 290 1710 {lab=VSS}
N 290 1710 290 1740 {lab=VSS}
N 60 1570 80 1570 {lab=VSS}
N 80 1570 80 1710 {lab=VSS}
N 270 1570 290 1570 {lab=VSS}
N 290 1570 290 1710 {lab=VSS}
N -10 1290 -10 1710 {lab=#net67}
N -10 1710 20 1710 {lab=#net67}
N 210 1290 230 1290 {lab=#net63}
N 210 1290 210 1710 {lab=#net63}
N 200 1290 210 1290 {lab=#net63}
N 210 1710 230 1710 {lab=#net63}
N -50 1490 20 1490 {lab=#net68}
N 20 1480 20 1490 {lab=#net68}
N 20 1480 240 1480 {lab=#net68}
N 20 1400 20 1480 {lab=#net68}
N 240 1480 240 1560 {lab=#net68}
N 230 1560 240 1560 {lab=#net68}
N 230 1560 230 1570 {lab=#net68}
N 230 1350 230 1410 {lab=S0}
N -140 1350 230 1350 {lab=S0}
N -140 1350 -140 1490 {lab=S0}
N -160 1570 20 1570 {lab=S0}
N -160 1490 -160 1570 {lab=S0}
N 60 1600 60 1680 {lab=#net69}
N 270 1600 270 1680 {lab=#net70}
N 370 1520 370 1740 {lab=VSS}
N 370 1260 370 1460 {lab=VDD}
N 290 1260 370 1260 {lab=VDD}
N -200 1260 -100 1260 {lab=VDD}
N -410 1260 -410 1280 {lab=VDD}
N -450 1740 -440 1400 {lab=VSS}
N -440 1400 -410 1400 {lab=VSS}
N -330 1290 -10 1290 {lab=#net67}
N -330 1290 -330 1340 {lab=#net67}
N -340 1340 -330 1340 {lab=#net67}
N 420 1490 540 1490 {lab=#net71}
N 590 1260 590 1450 {lab=VDD}
N 370 1260 590 1260 {lab=VDD}
N 590 1560 590 1740 {lab=VSS}
N 370 1740 590 1740 {lab=VSS}
N 290 1740 370 1740 {lab=VSS}
N 660 1510 730 1510 {lab=OUT}
N 740 950 740 1210 {lab=#net63}
N 210 1210 740 1210 {lab=#net63}
N 210 1210 210 1290 {lab=#net63}
N 740 420 740 660 {lab=#net54}
N 210 660 740 660 {lab=#net54}
N 210 660 210 730 {lab=#net54}
N 220 -440 220 -360 {lab=#net36}
N 220 -440 780 -440 {lab=#net36}
N 780 -440 790 -710 {lab=#net36}
N -450 -2350 580 -2340 {lab=CLK}
N -520 -1950 -390 -1950 {lab=CLK}
N -520 -2350 -520 -1950 {lab=CLK}
N -520 -2510 -380 -2510 {lab=CLK}
N -520 -2350 -450 -2350 {lab=CLK}
N -520 -2510 -520 -2350 {lab=CLK}
N -530 -1780 610 -1780 {lab=CLK}
N -530 -1950 -530 -1780 {lab=CLK}
N -530 -1950 -520 -1950 {lab=CLK}
N -530 1360 -460 1360 {lab=CLK}
N -530 -1780 -530 -1420 {lab=CLK}
N -530 -1420 -390 -1420 {lab=CLK}
N -530 -860 -400 -860 {lab=CLK}
N -370 -1380 -370 -1040 {lab=VSS}
N -380 -1040 -370 -1040 {lab=VSS}
N -530 -1250 -530 -860 {lab=CLK}
N -530 -1250 610 -1250 {lab=CLK}
N -530 -1420 -530 -1250 {lab=CLK}
N -530 -690 -530 -290 {lab=CLK}
N -530 -290 -440 -290 {lab=CLK}
N -530 -690 600 -690 {lab=CLK}
N -530 -860 -530 -690 {lab=CLK}
N -530 -120 -530 270 {lab=CLK}
N -530 270 -450 270 {lab=CLK}
N -530 440 -530 800 {lab=CLK}
N -530 800 -450 800 {lab=CLK}
N -530 970 -530 1360 {lab=CLK}
N -540 1360 -530 1360 {lab=CLK}
N -530 -120 560 -120 {lab=CLK}
N -530 -290 -530 -120 {lab=CLK}
N -530 440 550 440 {lab=CLK}
N -530 270 -530 440 {lab=CLK}
N -530 970 550 970 {lab=CLK}
N -530 800 -530 970 {lab=CLK}
N -540 1530 540 1530 {lab=CLK}
N -540 1360 -540 1530 {lab=CLK}
N -260 1180 -90 1180 {lab=VSS}
N -190 1740 -100 1740 {lab=VSS}
N -260 1180 -260 1740 {lab=VSS}
N -300 1180 -260 1180 {lab=VSS}
N -450 1740 -260 1740 {lab=VSS}
N -200 700 -200 1260 {lab=VDD}
N -400 700 -200 700 {lab=VDD}
N -410 1260 -200 1260 {lab=VDD}
N -260 90 -80 90 {lab=VSS}
N -300 650 -90 650 {lab=VSS}
N -300 90 -300 650 {lab=VSS}
N -430 90 -300 90 {lab=VSS}
N -440 650 -300 650 {lab=VSS}
N -190 -390 -190 170 {lab=VDD}
N -390 -390 -190 -390 {lab=VDD}
N -200 170 -190 170 {lab=VDD}
N -200 170 -200 700 {lab=VDD}
N -400 170 -200 170 {lab=VDD}
N -440 1180 -300 1180 {lab=VSS}
N -300 650 -300 1180 {lab=VSS}
N -270 -480 -260 90 {lab=VSS}
N -390 -480 -270 -480 {lab=VSS}
N -300 90 -260 90 {lab=VSS}
N -190 -960 -190 -390 {lab=VDD}
N -350 -960 -190 -960 {lab=VDD}
N -250 -1040 -240 -480 {lab=VSS}
N -370 -1040 -250 -1040 {lab=VSS}
N -270 -480 -240 -480 {lab=VSS}
N -190 -1520 -190 -960 {lab=VDD}
N -340 -1520 -190 -1520 {lab=VDD}
N -190 -2050 -190 -1520 {lab=VDD}
N -340 -2050 -190 -2050 {lab=VDD}
N -210 -1570 -210 -1040 {lab=VSS}
N -240 -1570 -210 -1570 {lab=VSS}
N -250 -1040 -210 -1040 {lab=VSS}
N -190 -2610 -190 -2050 {lab=VDD}
N -330 -2610 -190 -2610 {lab=VDD}
N -240 -2130 -240 -1570 {lab=VSS}
N -370 -2130 -240 -2130 {lab=VSS}
N -380 -1570 -240 -1570 {lab=VSS}
N 230 -2580 290 -2580 {lab=VSS}
N 230 -2580 230 -2130 {lab=VSS}
N 160 -2130 230 -2130 {lab=VSS}
N -70 -2300 -70 -1960 {lab=S0}
N -80 -2300 -70 -2300 {lab=S0}
N -90 -1740 -90 -1430 {lab=S0}
N -90 -1430 -70 -1430 {lab=S0}
N -90 -1210 -90 -860 {lab=S0}
N -90 -860 -80 -860 {lab=S0}
N -80 -870 -80 -860 {lab=S0}
N -100 -650 -100 -300 {lab=S0}
N -120 -300 -100 -300 {lab=S0}
N -140 -80 -140 260 {lab=S0}
N -140 260 -130 260 {lab=S0}
N -150 480 -150 790 {lab=S0}
N -150 790 -130 790 {lab=S0}
N -150 1010 -150 1350 {lab=S0}
N -150 1350 -140 1350 {lab=S0}
N -490 230 -450 230 {lab=D6}
N -490 760 -450 760 {lab=D7}
N -480 1320 -460 1320 {lab=D8}
N 600 1010 600 1180 {lab=VSS}
N 600 480 600 650 {lab=VSS}
N 610 -80 610 90 {lab=VSS}
N 650 -650 650 -480 {lab=VSS}
N 660 -1210 660 -1040 {lab=VSS}
N 660 -1740 660 -1570 {lab=VSS}
N 670 -2300 670 -2130 {lab=VSS}
N -80 -2620 -80 -2610 {lab=VDD}
N -190 -2610 -80 -2610 {lab=VDD}
N -190 1740 -190 1760 {lab=VSS}
N -260 1740 -190 1740 {lab=VSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 120 -2300 0 0 {name=MN5
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 120 -2580 0 0 {name=MP5
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {inv.sym} 20 -2290 0 0 {name=x3}
C {sg13g2_pr/sg13_lv_pmos.sym} 330 -2580 0 0 {name=MP6
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 120 -2470 0 0 {name=MP7
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 330 -2460 0 0 {name=MP8
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 330 -2300 0 0 {name=MN6
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 120 -2160 0 0 {name=MN7
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 330 -2160 0 0 {name=MN8
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {inv.sym} 490 -2290 0 0 {name=x4}
C {flipflop.sym} -210 -2530 0 0 {name=x5}
C {flipflop.sym} 790 -2360 0 0 {name=x6}
C {sg13g2_pr/sg13_lv_nmos.sym} 110 -1740 0 0 {name=MN9
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 110 -2020 0 0 {name=MP9
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {inv.sym} 10 -1730 0 0 {name=x7}
C {sg13g2_pr/sg13_lv_pmos.sym} 320 -2020 0 0 {name=MP10
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 110 -1910 0 0 {name=MP11
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 320 -1900 0 0 {name=MP12
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 320 -1740 0 0 {name=MN10
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 110 -1600 0 0 {name=MN11
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 320 -1600 0 0 {name=MN12
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {inv.sym} 480 -1730 0 0 {name=x8}
C {flipflop.sym} -220 -1970 0 0 {name=x9}
C {flipflop.sym} 780 -1800 0 0 {name=x10}
C {sg13g2_pr/sg13_lv_nmos.sym} 110 -1210 0 0 {name=MN13
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 110 -1490 0 0 {name=MP13
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {inv.sym} 10 -1200 0 0 {name=x11}
C {sg13g2_pr/sg13_lv_pmos.sym} 320 -1490 0 0 {name=MP14
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 110 -1380 0 0 {name=MP15
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 320 -1370 0 0 {name=MP16
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 320 -1210 0 0 {name=MN14
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 110 -1070 0 0 {name=MN15
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 320 -1070 0 0 {name=MN16
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {inv.sym} 480 -1200 0 0 {name=x12}
C {flipflop.sym} -220 -1440 0 0 {name=x13}
C {flipflop.sym} 780 -1270 0 0 {name=x14}
C {sg13g2_pr/sg13_lv_nmos.sym} 100 -650 0 0 {name=MN17
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 100 -930 0 0 {name=MP17
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {inv.sym} 0 -640 0 0 {name=x17}
C {sg13g2_pr/sg13_lv_pmos.sym} 310 -930 0 0 {name=MP18
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 100 -820 0 0 {name=MP19
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 310 -810 0 0 {name=MP20
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 310 -650 0 0 {name=MN18
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 100 -510 0 0 {name=MN19
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 310 -510 0 0 {name=MN20
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {inv.sym} 470 -640 0 0 {name=x18}
C {flipflop.sym} -230 -880 0 0 {name=x19}
C {flipflop.sym} 770 -710 0 0 {name=x20}
C {sg13g2_pr/sg13_lv_nmos.sym} 60 -80 0 0 {name=MN21
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 60 -360 0 0 {name=MP21
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {inv.sym} -40 -70 0 0 {name=x21}
C {sg13g2_pr/sg13_lv_pmos.sym} 270 -360 0 0 {name=MP22
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 60 -250 0 0 {name=MP23
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 270 -240 0 0 {name=MP24
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 270 -80 0 0 {name=MN22
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 60 60 0 0 {name=MN23
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 270 60 0 0 {name=MN24
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {inv.sym} 430 -70 0 0 {name=x22}
C {flipflop.sym} -270 -310 0 0 {name=x23}
C {flipflop.sym} 730 -140 0 0 {name=x24}
C {sg13g2_pr/sg13_lv_nmos.sym} 50 480 0 0 {name=MN25
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 50 200 0 0 {name=MP25
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {inv.sym} -50 490 0 0 {name=x25}
C {sg13g2_pr/sg13_lv_pmos.sym} 260 200 0 0 {name=MP26
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 50 310 0 0 {name=MP27
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 260 320 0 0 {name=MP28
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 260 480 0 0 {name=MN26
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 50 620 0 0 {name=MN27
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 260 620 0 0 {name=MN28
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {inv.sym} 420 490 0 0 {name=x26}
C {flipflop.sym} -280 250 0 0 {name=x27}
C {flipflop.sym} 720 420 0 0 {name=x28}
C {sg13g2_pr/sg13_lv_nmos.sym} 50 1010 0 0 {name=MN29
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 50 730 0 0 {name=MP29
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {inv.sym} -50 1020 0 0 {name=x29}
C {sg13g2_pr/sg13_lv_pmos.sym} 260 730 0 0 {name=MP30
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 50 840 0 0 {name=MP31
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 260 850 0 0 {name=MP32
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 260 1010 0 0 {name=MN30
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 50 1150 0 0 {name=MN31
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 260 1150 0 0 {name=MN32
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {inv.sym} 420 1020 0 0 {name=x30}
C {flipflop.sym} -280 780 0 0 {name=x31}
C {flipflop.sym} 720 950 0 0 {name=x32}
C {sg13g2_pr/sg13_lv_nmos.sym} 40 1570 0 0 {name=MN33
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 40 1290 0 0 {name=MP33
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {inv.sym} -60 1580 0 0 {name=x33}
C {sg13g2_pr/sg13_lv_pmos.sym} 250 1290 0 0 {name=MP34
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 40 1400 0 0 {name=MP35
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 250 1410 0 0 {name=MP36
l=130.00n
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 250 1570 0 0 {name=MN34
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 40 1710 0 0 {name=MN35
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 250 1710 0 0 {name=MN36
l=130.00n
w=740.00n
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {inv.sym} 410 1580 0 0 {name=x34}
C {flipflop.sym} -290 1340 0 0 {name=x35}
C {flipflop.sym} 710 1510 0 0 {name=x36}
C {ipin.sym} -450 -2550 0 0 {name=p3 lab=D1}
C {iopin.sym} -80 -2620 1 1 {name=p6 lab=VDD
}
C {iopin.sym} -190 1760 3 1 {name=p1 lab=VSS
}
C {opin.sym} 730 1510 0 0 {name=p4 lab=OUT}
C {ipin.sym} -460 -1990 0 0 {name=p2 lab=D2}
C {ipin.sym} -460 -1460 0 0 {name=p7 lab=D3}
C {ipin.sym} -460 -900 0 0 {name=p8 lab=D4}
C {ipin.sym} -500 -330 0 0 {name=p9 lab=D5}
C {ipin.sym} -490 230 0 0 {name=p10 lab=D6}
C {ipin.sym} -490 760 0 0 {name=p11 lab=D7}
C {ipin.sym} -480 1320 0 0 {name=p12 lab=D8}
C {ipin.sym} -60 -2450 0 0 {name=p13 lab=S0}
C {ipin.sym} -520 -2510 0 0 {name=p5 lab=CLK}
